# Keil uVision project proj.uvprojx, settings and files
target AT32F421 (6160000::V6.16::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.7
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: DutyCycle +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARDUINO=111,SYNCHRO_RES=800
  c include: ..\..\..\Application;..\..\..\ArduinoAPI;..\..\..\Libraries;..\Core;..\Config;..\..\..\..\..\App;..\..\..\..\..\..\Firmware;..\..\..\Application\flashdb_port;..\..\..\..\..\External\FlashDB\inc;..\..\..\..\..\External\FlashDB\port\fal\inc;..\..\..\Application\umm_malloc_port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x4000
  group App
    ../../../../../App/: App.cpp App.h Version.h
  group Service/DataProc
    ../../../../../App/Service/DataProc/: _DP_Template.cpp DataProc.cpp DataProc.h DataProc_Def.h DataProc_Helper.h DataProc_NodeList.inc DP_Button.cpp DP_Power.cpp DP_Version.cpp DP_WatchDog.cpp DP_Ctrl.cpp DP_Clock.cpp DP_TimeMonitor.cpp DP_Audio.cpp DP_Shell.cpp DP_KVDB.cpp DP_Alarm.cpp
  group Service/DataProc/Def
    ../../../../../App/Service/DataProc/Def/: _Template.h Battery.h Button.h Global.h Power.h Version.h Audio.h KVDB.h Shell.h Alarm.h Clock.h Ctrl.h TimeMonitor.h
  group Service/DataProc/Helper
    ../../../../../App/Service/DataProc/Helper/: _Template_Helper.cpp _Template_Helper.h Power_Helper.cpp Power_Helper.h Audio_Helper.cpp Audio_Helper.h KVDB_Helper.cpp KVDB_Helper.h MotorCtrl.cpp MotorCtrl.h
  group Service/HAL
    ../../../../../App/Service/HAL/: HAL.h HAL_Assert.h HAL_Def.h HAL_Log.h HAL_Template.cpp
  group Service/HAL/Def
    ../../../../../App/Service/HAL/Def/: _Template.h Battery.h Button.h Buzzer.h Clock.h Flash.h Power.h UID.h Tick.h WatchDog.h
  group Utils
    ../../../../../App/Utils/ButtonEvent/: ButtonEvent.cpp
    ../../../../../App/Utils/CommonMacro/: CommonMacro.h
    ../../../../../App/Utils/Filters/: Filters.h
    ../../../../../App/Utils/Shell/: Shell.c
    ../../../../../App/Utils/easing/: easing.c
    ../../../../../App/Utils/synchro/: synchro.c
  group Frameworks/DataBroker
    ../../../../../Frameworks/DataBroker/: DataBroker.cpp DataBroker.h DataBrokerLog.h DataNode.cpp DataNode.h DataTimer.cpp DataTimer.h
  group Frameworks/DeviceManager
    ../../../../../Frameworks/DeviceManager/: DeviceManager.cpp DeviceManager.h DeviceObject.h
  group External/FlashDB
    ../../../../../External/FlashDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
    ../../../../../External/FlashDB/port/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group External/argparse
    ../../../../../External/argparse/: argparse.c argparse.h
  group External/umm_malloc
    ../../../../../External/umm_malloc/src/: umm_info.c umm_integrity.c umm_malloc.c umm_poison.c
  group Application/HAL
    ../../../Application/HAL/: HAL.cpp HAL_DeviceTree.inc HAL.h HAL_Battery.cpp HAL_Button.cpp HAL_Config.h HAL_FaultHandle.cpp HAL_Log.cpp HAL_MemoryInfo.cpp HAL_Power.cpp HAL_Tick.cpp HAL_WatchDog.cpp HAL_Clock.cpp HAL_Buzzer.cpp HAL_Motor.cpp HAL_MotorSynchro.cpp HAL_SerialIO.cpp HAL_Flash.cpp HAL_MPU.cpp HAL_PinRemap.cpp HAL_UID.cpp
  group Application/flashdb_port
    ../../../Application/flashdb_port/: fal_cfg.h fal_port.cpp fdb_cfg.h
  group Application/umm_malloc_port
    ../../../Application/umm_malloc_port/: new.cpp umm_malloc_cfgport.h umm_malloc_port.c
  group Application
    ../../../Application/: main.cpp rt_sys.cpp
  group Config
    ../Config/: mcu_config.h
  group Libraries
    ../../../Libraries/StackInfo/: StackInfo.c
    ../../../Libraries/cm_backtrace/: cm_backtrace.c
  group ArduinoAPI
    ../../../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp Stream.cpp Tone.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group Core
    ../Core/: mcu_type.h mcu_core.h mcu_core.c at32f421_clock.c adc.c delay.c exti.c gpio.c timer.c pwm.c rtc.c HardwareSerial.cpp SPI.cpp wdg.c
  group README
    ../../../: README.md
software components: CMSIS:CORE 5.5.0, Device:Startup 2.0.0, Device:at32f421_conf 2.0.0, Device:at32f421_firmware_library:adc 2.0.0, Device:at32f421_firmware_library:cmp 2.0.0, Device:at32f421_firmware_library:crc 2.0.0, Device:at32f421_firmware_library:crm 2.0.0, Device:at32f421_firmware_library:debug 2.0.0, Device:at32f421_firmware_library:dma 2.0.0, Device:at32f421_firmware_library:ertc 2.0.0, Device:at32f421_firmware_library:exint 2.0.0, Device:at32f421_firmware_library:flash 2.0.0, Device:at32f421_firmware_library:gpio 2.0.0, Device:at32f421_firmware_library:i2c 2.0.0, Device:at32f421_firmware_library:misc 2.0.0, Device:at32f421_firmware_library:pwc 2.0.0, Device:at32f421_firmware_library:scfg 2.0.0, Device:at32f421_firmware_library:spi 2.0.0, Device:at32f421_firmware_library:tmr 2.0.0, Device:at32f421_firmware_library:usart 2.0.0, Device:at32f421_firmware_library:wdt 2.0.0, Device:at32f421_firmware_library:wwdt 2.0.0
